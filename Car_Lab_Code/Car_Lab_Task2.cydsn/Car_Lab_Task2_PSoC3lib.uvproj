# Keil uVision project Car_Lab_Task2_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: Car_Lab_Task2_PSoC3lib (library)
  c flags: Optimize=2
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h LCD.c LCD.h LCD_PM.c LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h MOSFET.c MOSFET.h MOSFET_PM.c Clk.c Clk.h Drive.c Drive.h Drive_aliases.h clk_inter.c clk_inter.h Hall.c Hall.h Hall_aliases.h spd_inter.c spd_inter.h Servo.c Servo.h Servo_PM.c Servo_Clk.c Servo_Clk.h Servo_Drive.c Servo_Drive.h Servo_Drive_aliases.h Servo_Gnd.c Servo_Gnd.h Servo_Gnd_aliases.h Counter.c Counter.h Counter_PM.c VSync.c VSync.h VSync_aliases.h CSync.c CSync.h CSync_aliases.h Clk_1.c Clk_1.h LineCounter.c LineCounter.h LineCounter_PM.c CV.c CV.h CV_aliases.h VRef.c VRef.h Thresholder.c Thresholder.h Thresholder_PM.c Clk_2.c Clk_2.h Line_Timer.c Line_Timer.h Line_Timer_PM.c Clk_3.c Clk_3.h timer_inter.c timer_inter.h VRef_PM.c Clk_4.c Clk_4.h Clk_5.c Clk_5.h LineCounter_bot.c LineCounter_bot.h LineCounter_bot_PM.c Line_Timer_bot.c Line_Timer_bot.h Line_Timer_bot_PM.c timer_inter_bot.c timer_inter_bot.h
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: Car_Lab_Task2_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
