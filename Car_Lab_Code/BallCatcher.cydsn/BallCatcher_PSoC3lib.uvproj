# Keil uVision project BallCatcher_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: BallCatcher_PSoC3lib (library)
  c flags: Optimize=2
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h FR_HBridge.c FR_HBridge.h FR_HBridge_PM.c FR_H.c FR_H.h FR_H_aliases.h LCD.c LCD.h LCD_PM.c LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h FR_H2.c FR_H2.h FR_H2_aliases.h BR_HBridge.c BR_HBridge.h BR_HBridge_PM.c BR_H2.c BR_H2.h BR_H2_aliases.h BR_H.c BR_H.h BR_H_aliases.h FL_HBridge.c FL_HBridge.h FL_HBridge_PM.c FL_H2.c FL_H2.h FL_H2_aliases.h FL_H.c FL_H.h FL_H_aliases.h BL_HBridge.c BL_HBridge.h BL_HBridge_PM.c BL_H2.c BL_H2.h BL_H2_aliases.h BL_H.c BL_H.h BL_H_aliases.h PixyPan.c PixyPan.h PixyPan_aliases.h Pan_int.c Pan_int.h Pan_Reset.c Pan_Reset.h timer_clock.c timer_clock.h PanTime.c PanTime.h PanTime_PM.c pan_reset_clk.c pan_reset_clk.h PixyTilt.c PixyTilt.h PixyTilt_aliases.h TiltTime.c TiltTime.h TiltTime_PM.c timer_clock_1.c timer_clock_1.h Tilt_int.c Tilt_int.h Tilt_Reset.c Tilt_Reset.h tilt_reset_clk.c tilt_reset_clk.h PWM_clk.c PWM_clk.h Gyro_Pin.c Gyro_Pin.h Gyro_Pin_aliases.h ADC.c ADC.h ADC_PM.c ADC_INT.c Analog_int.c Analog_int.h Range_Pin.c Range_Pin.h Range_Pin_aliases.h ADC_theACLK.c ADC_theACLK.h ADC_Ext_CP_Clk.c ADC_Ext_CP_Clk.h ADC_AMux.c ADC_AMux.h Clock_2.c Clock_2.h Range_int.c Range_int.h gyro_int.c gyro_int.h AMux_Sel.c AMux_Sel.h AMux_Sel_PM.c Detect_pin.c Detect_pin.h Detect_pin_aliases.h Detection_Status.c Detection_Status.h
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: BallCatcher_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
